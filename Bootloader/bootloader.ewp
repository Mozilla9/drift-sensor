# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bootloader.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2364 NXP LPC2364
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pe550
  ICCARM.CCIncludePath2: ; Config\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: bootloader.hex
  ILINK.IlinkIcfFile: Config\LPC2364_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup.s main.c
  group AT25DF
    At25df/: at25df.c
  group BOOTLOADER
    Bootloader/: bootloader.c
  group CORE
    Core/: core.c
  group FMEM
    Fmem/: fmem.c
  group IAP
    Iap/: bl_iap.c iap.c
  group LED
    Led/: led.c
  group LIB
    Lib/: bin_to_bcd.c float_to_txt.c
  group REVISION
    Revision/: revision.c revision.h svnrev.h
  group RING_BUFFER
    Ringbuff/: ring_buffer.c
  group SDP
    Sdp/: sdp.c sdp_handlers.c test.txt
  group SETT
    Sett/: settings.c
  group SPI
    Spi/: spi.c
  group TASKS
    Tasks/: tasks.c
  group UART
    Uart/: uart0.c v_printf.c v_printf_impl.c
  group UPDATER
    Updater/: updater.c
