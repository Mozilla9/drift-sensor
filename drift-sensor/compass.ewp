# IAR project compass.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2364 NXP LPC2364
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pe550
  ICCARM.CCIncludePath2: ; Config\
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: compass.hex
  ILINK.IlinkIcfFile: Config\LPC2364_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup.s main.c
  group AT25DF
    At25df/: at25df.c
    Spi/: spi.c
  group COMPASS
    Compass/: compass.c
  group CONSOLE
    Microrl/: handlers.c microrl.c
  group CORE
    Core/: core.c
  group DRIFT
    Drift/: calibrating.c drift.c
  group FILTER
    Filter/: average.c
  group FMEM
    Fmem/: fmem.c
  group I2C
    I2C/: i2c0.c
  group LED
    Led/: led.c
  group LIB
    Lib/: bin_to_bcd.c float_to_txt.c
  group LIS3DH
    Lis3dh/: lis3dh.c
  group MATRIX
    Matrix/: calibrovka.txt matrix.c
  group RINGBUFF
    Ringbuff/: ring_buffer.c
  group SETT
    Sett/: settings.c
  group TASKS
    Tasks/: tasks.c
  group UART
    Uart/: uart0.c uart2.c v_printf.c
